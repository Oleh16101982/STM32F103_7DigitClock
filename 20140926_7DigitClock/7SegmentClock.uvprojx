# Keil uVision project 7SegmentClock.uvprojx, settings and files
target Clock (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 7SegmentClock +hex
  c flags: Optim=1
  c define: STM32F10X_LD_VL, USE_STDPERIPH_DRIVER
  c include: .\main\inc;.\lib\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ./: startup_stm32f10x_ld_vl.s
  group main
    ./main/src/: main.c stm32f10x_it.c show.c RtcBcdValue.c AlarmBcdValue.c TemperatureBcdValue.c
  group STM32
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../_stm32f1xx/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../_stm32f1xx/CMSIS/CM3/CoreSupport/: core_cm3.c
  group library
    ./lib/src/: bcdhex.c rtc.c
software components: CMSIS:CORE 4.1.0
